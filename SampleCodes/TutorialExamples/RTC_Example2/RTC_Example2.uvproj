# Keil uVision project RTC_Example2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTC_Example2 +hex
  c flags: Optim=1
  c include: ..\..\Keil_Sample_Code\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    ../../Keil_Sample_Code/00-libfiles/: delay.c delay.h gpio.c gpio.h lcd.c lcd.h rtc.c rtc.h stdutils.h systemInit.c systemInit.h
