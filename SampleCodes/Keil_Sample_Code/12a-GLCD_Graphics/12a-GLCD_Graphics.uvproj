# Keil uVision project 12a-GLCD_Graphics.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 12a-GLCD_Graphics +hex
  AfterMake: fromelf --bin 12a-GLCD_Graphics.axf --output 12a-GLCD_Graphics.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    ../00-libfiles/: glcd.c systemInit.c stdutils.h systemInit.h gpio.c gpio.h glcd.h delay.c delay.h
