# Keil uVision project 09a-RTC_UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 09a-RTC_UART +hex
  AfterMake: fromelf --bin Objects\09a-RTC_UART.axf --output 09a-RTC_UART.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: Startup.s main.c
    ../00-libfiles/: gpio.c rtc.c systemInit.c uart.c
  group Header
    ../00-libfiles/: gpio.h rtc.h stdutils.h uart.h systemInit.h
