# Keil uVision project ExploreLPC2148_Board_Test.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ExploreLPC2148_Board_Test
  AfterMake: fromelf --bin Objects\ExploreLPC2148_Board_Test.axf --output LPC2148_Board_Test.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: Startup.s main.c
    ../00-libfiles/: adc.c delay.c eeprom.c gpio.c keypad.c lcd.c pwm.c rtc.c softi2c.c systemInit.c uart.c
  group Header
    ../00-libfiles/: adc.h delay.h eeprom.h gpio.h keypad.h lcd.h pwm.h rtc.h softi2c.h stdutils.h uart.h
