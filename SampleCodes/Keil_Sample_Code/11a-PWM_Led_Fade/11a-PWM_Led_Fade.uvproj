# Keil uVision project 11a-PWM_Led_Fade.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 11a-PWM_Led_Fade
  AfterMake: fromelf --bin Objects\11a-PWM_Led_Fade.axf --output 11a-PWM_Led_Fade.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: Startup.s main.c
    ../00-libfiles/: delay.c gpio.c pwm.c systemInit.c
  group Header
    ../00-libfiles/: delay.h gpio.h pwm.h stdutils.h
