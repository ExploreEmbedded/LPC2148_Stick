# Keil uVision project 02a-SwitchLed.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 02a-SwitchLed
  AfterMake: fromelf --bin Objects\02a-SwitchLed.axf --output 02a-SwitchLed.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    ../00-libfiles/: gpio.c
  group Header
    ../00-libfiles/: gpio.h stdutils.h
