# Keil uVision project 08b-Eeprom_String_RdWr.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 08b-Eeprom_String_RdWr +hex
  c flags: Optim=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    ../00-libfiles/: delay.c delay.h eeprom.c eeprom.h gpio.c gpio.h softi2c.c softi2c.h stdutils.h systemInit.c systemInit.h uart.c uart.h
