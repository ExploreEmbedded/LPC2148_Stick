# Keil uVision project 01a-LedBlinking.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 01a-LedBlinking
  AfterMake: fromelf --bin Objects\01a-LedBlinking.axf --output 01a-LedBlinking.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
