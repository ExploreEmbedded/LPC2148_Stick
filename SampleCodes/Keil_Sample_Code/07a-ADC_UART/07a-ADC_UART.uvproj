# Keil uVision project 07a-ADC_UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 07a-ADC_UART
  AfterMake: fromelf --bin Objects\07a-ADC_UART.axf --output 07a-ADC_UART.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: Startup.s main.c
    ../00-libfiles/: adc.c delay.c gpio.c systemInit.c uart.c
  group Header
    ../00-libfiles/: adc.h delay.h gpio.h stdutils.h uart.h systemInit.h
